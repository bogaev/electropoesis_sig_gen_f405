<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\405_PA_Add.ewp</path>
  </project>
  <batchBuild />
</workspace>
